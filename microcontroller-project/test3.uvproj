# Keil uVision project test3.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F310 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: test3
  c flags: Optimize=8 SizeSpeed=1
  group inc
    ./asm/: C8051F310.INC KeBeep.inc KeLED.inc LED.inc Beep.inc GlobalVars.inc KeTimer2.inc Timer.inc KeKeys.inc KeLEDs.inc LEDs.inc Keys.inc KeDigits.inc Digits.inc homework.inc password.inc test3.inc CAL.INC
  group startup
    ./asm/: C8051F310.asm
  group user
    ./asm/: test3.asm homework.asm password.asm CAL.ASM
  group API
    ./asm/: LED.asm Beep.asm Timer.asm LEDs.asm Keys.asm Digits.asm
  group kernel
    ./asm/: KeLED.asm KeBeep.asm KeKeys.asm KeTimer2.asm KeLEDs.asm KeDigits.asm
